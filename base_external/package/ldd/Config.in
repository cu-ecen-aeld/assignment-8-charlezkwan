## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "aesd-ldd"
	help
	  Build and install misc-modules and scull components.
```
